options:
  parameters:
    generate_options: no_gui
    id: pulsar_filterbank_uhd
    output_language: python
    run: 'False'
    run_options: run
  states: {}

blocks:
- name: an_fftsize
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: analyser_result
  id: variable
  parameters:
    value: fb_helper.analyser(analysis_poll_fast,fbsize)
  states: {}
- name: analysis_poll_fast
  id: variable_function_probe
  parameters:
    block_id: analysis_probe
    function_name: level
    poll_rate: '4'
    value: '[0.0]*an_fftsize'
  states: {}
- name: analysis_poll_slow
  id: variable_function_probe
  parameters:
    block_id: analysis_probe
    function_name: level
    poll_rate: '0.3333'
    value: '[0.0]*an_fftsize'
  states: {}
- name: cfname
  id: variable
  parameters:
    value: '"/dev/null" if wide == 1 else pfname+".filtmp"'
  states: {}
- name: fbdecim
  id: variable
  parameters:
    value: '1 if decimation==0  else fb_helper.determine_rate(samp_rate,fbsize,pw50)  '
  states: {}
- name: fbrate
  id: variable
  parameters:
    comment: Output sample rate for each channel
    value: (float(samp_rate)/float(fbsize))/float(fbdecim)
  states: {}
- name: fbsize
  id: variable
  parameters:
    value: fb_helper.dm_to_bins(dm,fb_helper.get_sky_freq(sky,freq),samp_rate,pw50)*resolution
  states: {}
- name: fft_log_status
  id: variable
  parameters:
    comment: |-
      Arrange to log FFT outputs in dB ascii
      format every 10 seconds
    value: fb_helper.log_fft(fb_helper.get_sky_freq(sky,freq),samp_rate,prefix,fft_poll2)
  states: {}
- name: fft_poll
  id: variable_function_probe
  parameters:
    block_id: fft_probe
    function_name: level
    poll_rate: '50'
    value: '[1.0e-15]*fbsize'
  states: {}
- name: fft_poll2
  id: variable_function_probe
  parameters:
    block_id: fft_probe
    function_name: level
    poll_rate: '5'
    value: '[1.0e-15]*fbsize'
  states: {}
- name: fft_rate
  id: variable
  parameters:
    value: samp_rate/fbsize
  states: {}
- name: hdr2_stat
  id: variable
  parameters:
    value: fb_helper.build_header_info(pfname+".fil",source,ra,dec,fb_helper.get_sky_freq(sky,freq),srate,fbrate,fbsize,None,swidth,antenna,backend)
  states: {}
- name: hdstatus
  id: variable
  parameters:
    value: fb_helper.write_header(parmname, fb_helper.get_sky_freq(sky,freq)/1.0e6, samp_rate/1.0e6, fbsize, fbrate,swidth)
  states: {}
- name: hpcorner
  id: variable
  parameters:
    value: (1.0/p0)/20.0
  states: {}
- name: lpcorner
  id: variable
  parameters:
    value: (1.0/pw50)*2.5
  states: {}
- name: ltp
  id: variable
  parameters:
    value: time.gmtime(time.time())
  states: {}
- name: magn
  id: variable
  parameters:
    value: fb_helper.get_current_estimate()
  states: {}
- name: parmname
  id: variable
  parameters:
    value: prefix+"psr-"+timestr+".header"
  states: {}
- name: pfname
  id: variable
  parameters:
    value: prefix+"psr-"+timestr
  states: {}
- name: prof_file
  id: variable
  parameters:
    value: prefix+"psr-"+timestr+"-profile.json" if profile else '/dev/null'
  states: {}
- name: profile_dec
  id: variable
  parameters:
    value: '2'
  states: {}
- name: reduced_rate
  id: variable
  parameters:
    value: fbrate/profile_dec
  states: {}
- name: rfi_mask
  id: variable
  parameters:
    comment: Computed statically from RFI list
    value: fb_helper.static_mask(fb_helper.get_sky_freq(sky,freq),samp_rate,fbsize,rfilist)
  states: {}
- name: rfi_mask2
  id: variable
  parameters:
    comment: |-
      Computed dynamically
      using estimate of mean power
    value: fb_helper.dynamic_mask(fft_poll,rfi_mask,thresh)
  states: {}
- name: rx_time_tags
  id: variable_function_probe
  parameters:
    block_id: tag_retrieve
    function_name: current_tags
    poll_rate: '30'
    value: '[]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: srate
  states: {}
- name: sfname
  id: variable
  parameters:
    value: '"/dev/null" if wide == 0 else pfname+".filtmp"'
  states: {}
- name: shaper
  id: variable
  parameters:
    comment: |-
      This provides passband response correction
      We merge in to the RFI excision masker, to
      eliminate an extra multiply-const
    value: fb_helper.get_correction(fbsize,rolloff,fft_poll2)
  states: {}
- name: swidth
  id: variable
  parameters:
    value: 1 if wide == 0 else 2
  states: {}
- name: tag_stash_result
  id: variable
  parameters:
    value: fb_helper.process_tag(rx_time_tags)
  states: {}
- name: timestr
  id: variable
  parameters:
    comment: Filename forming
    value: '"%04d%02d%02d%02d%02d" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday,ltp.tm_hour,ltp.tm_min)'
  states: {}
- name: update_header
  id: variable
  parameters:
    value: fb_helper.update_header(rx_time_tags, runtime, swidth,test,fbsize,fbrate,parmname)
  states: {}
- name: Folder_Block
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import time
      import json

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """A pulsar folder/de-dispersion block"""

          def __init__(self, fbsize=16,smear=10.0,period=0.714,filename='/dev/null',fbrate=2500,tbins=250,interval=30,tppms="0.0"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Pulsar Folder',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=None
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              
              self.set_output_multiple(fbsize)
              self.delaymap = [0]*fbsize
              delayincr = (smear/1000.0) * float(fbrate)
              delayincr /= float(fbsize)
              delayincr = round(delayincr)
              delayincr = int(delayincr)
              for i in range(fbsize):
                  self.delaymap[(fbsize-i)-1] = i*delayincr
              
              #
              # Needed in a few places
              #
              self.flen = fbsize
              
              #
              # The pulsar period
              #
              self.p0 = period
              
              #
              # The derived single-period pulse profile with various shifts
              #
              #
              ppmlist = tppms.split(",")
              self.shifts = []
              for p in ppmlist:
                  self.shifts.append(float(p)*1.0e-6)
                  
              self.profiles = [[0.0]*tbins]*len(self.shifts)
              self.pcounts = [[0.0]*tbins]*len(self.shifts)
              self.nprofiles = len(self.profiles)
              
              #
              #
              # How much time is in each bin?
              # The profile should be "exactly" as long as a single
              #   pulse period
              #
              self.tbint = []
              for shift in self.shifts:
                  self.tbint.append((self.p0*(1.0+shift))/tbins)
              
              #
              # The profile length
              #   
              self.plen = tbins
              
              #
              # Sample period
              #
              self.sper = 1.0/fbrate
              
              #
              # Mission Elapsed Time
              # This is moved along at every time samples arrival--incremented
              #   by 'self.sper'
              #
              self.MET = 0.0
              
              #
              # Open the output file
              #
              self.fname = filename
              self.sequence = 0
              
              self.max_in = 0.0
              self.min_in = 100000000
              
              #
              # The logging interval
              #
              self.INTERVAL = fbrate*interval
              self.logcount = self.INTERVAL
              
              #print "tbin %-11.7f tbinp %-11.7f tbinn %-11.7f" % (self.tbin, self.tbinp, self.tbinn)
              fp = open(self.fname, "w")
              fp.write ("[\n")
              fp.close()
              
          def work(self, input_items, output_items):
              """Do dedispersion/folding"""
              q = input_items[0]
              l = len(q)
              if (l > self.max_in):
                  self.max_in = l
              elif (l < self.min_in):
                  self.min_in = l
              for i in range(int(l/self.flen)):
                  #
                  # Do delay/dedispersion logic
                  #
                  if (self.delaymap[0] > 0):
                      outval = 0.0
                      for j in range(self.flen):
                          if (self.delaymap[j] == 0):
                              outval += q[(i*self.flen)+j]
                      #
                      # Decrement delay counters
                      #
                      for j in range(self.flen):
                          if (self.delaymap[j] > 0):
                              self.delaymap[j] -= 1
                          else:
                              break
                  else:
                      outval = sum(q[(i*self.flen):(i*self.flen)+self.flen])
                  
                  #
                  # Figure out where this sample goes in the profile buffer, based on MET
                  # We place the next sample based on the MET, re-expressed in terms of
                  #   total time-bins (self.tbint) modulo the profile length
                  #
                  # Update all the profiles
                  #
                  for x in range(self.nprofiles):
                      where = self.MET/self.tbint[x]
                      where = int(where) % self.plen
                      self.profiles[x][where] += outval
                      self.pcounts[x][where] += 1
                  
                  #
                  # Increment Mission Elapsed Time
                  #
                  self.MET += self.sper
                  
                  #
                  # Decrement the log counter
                  #
                  self.logcount -= 1
                  
                  #
                  # If time to log, the output is the reduced-by-counts
                  #  value of the profile.
                  #
                  if (self.logcount <= 0):
                      fp = open(self.fname, "a")
                      outputs = []
                      for x in range(len(self.profiles)):
                          outputs.append(np.divide(self.profiles[x],self.pcounts[x]))
                      d = {}
                      t = time.gmtime()
                      d["time"] = "%04d%02d%02d-%02d:%02d:%02d" % (t.tm_year,
                          t.tm_mon, t.tm_mday, t.tm_hour, t.tm_min, t.tm_sec)
                      d["sequence"] = self.sequence
                      d["max_input_length"] = self.max_in
                      d["min_input_length"] = self.min_in
                      self.sequence += 1
                      profiles = []
                      for x in range(len(self.profiles)):
                          pd = {}
                          pd["profile"] = list(outputs[x])
                          pd["p0"] = self.p0*(1.0+self.shifts[x])
                          pd["shift"] = self.shifts[x]
                          profiles.append(pd)
                      d["profiles"] = profiles
                      fp.write(json.dumps(d, indent=4, sort_keys=True)+",\n")
                      fp.close()
                      self.logcount = self.INTERVAL
                  
                  
              return len(q)
    fbrate: reduced_rate
    fbsize: fbsize
    filename: prof_file
    interval: pinterval
    period: p0
    smear: fb_helper.dm_to_smear(freq,samp_rate,dm)
    tbins: tbins
    tppms: trial_ppms
  states: {}
- name: IF
  id: parameter
  parameters:
    label: ' IF Tuner Frequency'
    type: eng_float
    value: 0.525e9
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: int(2**21)
    seed: '0'
    type: float
  states: {}
- name: analysis_probe
  id: blocks_probe_signal_vx
  parameters:
    type: float
    vlen: an_fftsize
  states: {}
- name: antenna
  id: parameter
  parameters:
    label: 'Antenna name '
    type: intx
    value: '67'
  states: {}
- name: backend
  id: parameter
  parameters:
    label: Backend type
    type: intx
    value: '66'
  states: {}
- name: bbgain
  id: parameter
  parameters:
    label: Baseband Gain
    type: eng_float
    value: '10'
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
    vlen: fbsize
  states: {}
- name: blocks_abs_xx_1
  id: blocks_abs_xx
  parameters:
    type: float
    vlen: fbsize
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
    vlen: fbsize
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    type: float
    vlen: fbsize
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: '"Detect" each channel'
    vlen: fbsize
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: an_fftsize
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: cfname
    type: byte
    vlen: fbsize
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: sfname
    type: short
    vlen: fbsize
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    comment: |-
      Whether we produce 8-bit or 16-bit files
      depends on the "wide" input parameter.
    scale: float(dscale) if dscale >= 0 else fb_helper.autoscale(abs(dscale),fft_poll2)
    vlen: fbsize
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: Flip I/Q, effect spectral inversion
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: float(dscale) if dscale >= 0 else fb_helper.autoscale(abs(dscale),fft_poll2)
    vlen: fbsize
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    comment: So we can control the observation run time
    num_items: int(runtime*samp_rate)
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: fbdecim
    type: float
    vlen: fbsize
  states: {}
- name: blocks_integrate_xx_1
  id: blocks_integrate_xx
  parameters:
    decim: fbsize
    type: float
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    comment: Decimate down to post-detect rate
    n: fbdecim
    type: float
    vlen: fbsize
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/15.0)
    type: complex
  states: {}
- name: blocks_keep_one_in_n_2
  id: blocks_keep_one_in_n
  parameters:
    n: '10'
    type: float
    vlen: fbsize
  states: {}
- name: blocks_keep_one_in_n_3
  id: blocks_keep_one_in_n
  parameters:
    n: profile_dec if profile == 1 else 100
    type: float
    vlen: fbsize
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: First stage RFI excision
    const: numpy.multiply(rfi_mask2,shaper)
    type: float
    vlen: fbsize
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '[0.0] * fbsize if hp == 0 else [hpgain]*fbsize'
    type: float
    vlen: fbsize
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: fb_helper.invert_rfi_mask(rfi_mask2)*numpy.array([magn]*fbsize)
    type: float
    vlen: fbsize
  states: {}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: '[float(fbdecim)]*fbsize if integrator == 0 else [0.0]*fbsize'
    type: float
    vlen: fbsize
  states: {}
- name: blocks_multiply_const_vxx_4
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1.0]*fbsize if integrator == 1 else [0.0]*fbsize'
    type: float
    vlen: fbsize
  states: {}
- name: blocks_multiply_const_vxx_5
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      This effectively selects which channel we are
      currently observing for detected modulation 
      artifacts
    const: fb_helper.get_current_channel(analysis_poll_slow,fbsize)
    type: float
    vlen: fbsize
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fbsize
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fbsize
    type: float
  states: {}
- name: blocks_stream_to_vector_2
  id: blocks_stream_to_vector
  parameters:
    num_items: an_fftsize
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    comment: |-
      Implement DC block
      Subtract long-term average from current
      samples
    type: float
    vlen: fbsize
  states: {}
- name: blocks_tags_strobe_0
  id: blocks_tags_strobe
  parameters:
    key: pmt.intern("local_tick")
    nsamps: '1'
    type: complex
    value: pmt.from_bool(True)
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fbsize
    type: float
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: fbsize
    type: float
  states: {}
- name: copyblock
  id: blocks_copy
  parameters:
    enabled: 'True'
    showports: 'True'
    type: complex
  states: {}
- name: dec
  id: parameter
  parameters:
    label: Source DEC
    type: eng_float
    value: '54.58'
  states: {}
- name: decimation
  id: parameter
  parameters:
    label: 'On/off decimation '
    type: intx
    value: '1'
  states: {}
- name: dm
  id: parameter
  parameters:
    label: Dispersion Measure
    type: eng_float
    value: '26.76'
  states: {}
- name: dscale
  id: parameter
  parameters:
    label: Detector scaling
    type: intx
    value: '1'
  states: {}
- name: fb_helper
  id: epy_module
  parameters:
    comment: |-
      Helper Module

      - determine suitable output sample rate
      - determine suitable FB size
      - write header info
      - provide a synchronization helper
      - provide a .FIL file header writer
      - process rx_time tag and update header
      - do RFI estimation and mask generation
      - compute passband correction
      - provide auto-scale option for output
    source_code: "# this module will be imported in the into your flowgraph\nimport time\nimport os\nimport shutil\nimport math\nimport struct\nimport pmt\nimport numpy\nimport random\n\nsmpwidth = 0\n\n#\n# Determine reasonable decimation value, given sample-rate,\n#  filterbank-size (already determined) and pw50 for the\n#  target pulsar.\n#\n# This is not stunningly efficient, but it only has to run\n#  ONCE on startup.\n#\ndef determine_rate(srate,fbsize,pw50):\n    decims = [1024,512,256,128,64,32,16,8,4,2,1]\n    target_rate = (1.0/pw50)\n    target_rate *= 10.0\n    for d in decims:\n        if ((srate/fbsize)/d >= target_rate):\n            return d\n    return 1\n\ndef dm_to_smear(freq,bw,dm):\n    f_lower = (freq-(bw/2.0))*1.0e-6\n    f_upper = (freq+(bw/2.0))*1.0e-6\n    Dt = 4.15e6 * (math.pow(f_lower,-2.0)-math.pow(f_upper,-2.0))\n    Dt *= dm\n    return Dt\n\n#\n# Convert DM to a reasonable number of FFT bins, given\n#  DM, center-frequency, bandwidth, and pw50\n# \ndef dm_to_bins(dm,freq,bw,pw50):\n    \n    #\n    # Convert pw50 to milliseconds (sigh)\n    #\n    p50ms = pw50 * 1000.0\n    \n    Dt = dm_to_smear(freq,bw,dm)\n    \n    #\n    # So that there's only 25% (of W50) residual smearing in each channel of the FB\n    #\n    required_bins = Dt/(p50ms/4.0)\n    \n    #\n    # We do a bit of base2 math to make this a nice FFT size\n    #\n    bins = math.log(required_bins)/math.log(2.0)\n    if (abs(bins-int(bins)) > 0.2):\n        bins += 1\n    \n    bins = int(bins)\n    \n    #\n    # No sense making the filterbank too small\n    # Set bins so that minimum is 4 channels\n    if bins < 2:\n        bins = 2\n\n    return(int(2**bins))\n\n#\n# Write an external, text, header file\n#\ndef write_header(fn, freq, bw, fbsize, fbrate, smpsize):\n    global smpwidth\n    \n    if (smpwidth == 0):\n        smpwidth = smpsize\n        \n    f = open(fn, \"w\")\n    ltp = time.gmtime(time.time())\n    f.write(\"frequency=%.5f\\n\" % freq)\n    f.write(\"RF sample rate=%.5f\\n\" % bw)\n    f.write(\"Filterbank Size=%d\\n\" % fbsize)\n    f.write(\"Filterbank output rate=%.6f\\n\" % fbrate)\n    f.write(\"Approx start UTC Date=%04d%02d%02d\\n\" % (ltp.tm_year,\n        ltp.tm_mon, ltp.tm_mday))\n    f.write(\"Approx start UTC Time=%02d:%02d:%02d\\n\" % (ltp.tm_hour,\n        ltp.tm_min, ltp.tm_sec))\n    f.write(\"Output sample size %d bytes\\n\" % smpsize)\n    f.write(\"Expected disk write rate: %6.2f mbyte/sec\\n\" % ((fbsize*fbrate*smpsize)/1.0e6))\n    \n\n\nheader_args = {}\n\n#\n# Convert to the weirdness that is the hybrid floating-point\n#  time format used by SIGPROC\n#\ndef convert_sigproct(v):\n    itime = int(v*3600.0)\n    hours = itime//3600\n    minutes = (itime-(hours*3600))//60\n    seconds = itime - (hours*3600) - (minutes*60)\n    timestr=\"%02d%02d%02d.0\" % (hours, minutes, seconds)\n    return(float(timestr))\n  \n#\n# This will cause a header block to be prepended to the output file\n#\n# Thanks to Guillermo Gancio (ganciogm@gmail.com) for the inspiration\n#   and much of the code\n#\n\ndef build_header_info(outfile,source_name,source_ra,source_dec,freq,bw,fbrate,fbsize,rx_time,smpsize,antenna,backend):\n    global smpwidth\n    \n    if (smpwidth == 0):\n        smpwidth = smpsize\n##################################################### no tocar luego se usa \n    header_args[\"outfile\"] = outfile\n    header_args[\"source_name\"] = source_name\n    header_args[\"source_ra\"] = source_ra\n    header_args[\"source_dec\"] = source_dec\n    header_args[\"freq\"] = freq\n    header_args[\"bw\"] = bw\n    header_args[\"fbrate\"] = fbrate\n    header_args[\"fbsize\"] = fbsize\n    header_args[\"antenna\"] = antenna\n    header_args[\"backend\"] = backend\n#####################################################\n\n    #\n    # Time for one sample, in sec\n    #\n    tsamp=1.0/fbrate\n    \n    #\n    # Frequency offset between channels, in MHz\n    #\n    f_off=bw/fbsize\n    f_off /= 1.0e6\n    f_off *= -1\n    \n    #\n    # Highest frequency represented in FB, in MHz\n    #\n    high_freq = freq+(bw/2.0)\n    high_freq  /= 1.0e6\n    high_freq -= (f_off/2.0)\n    \n    #\n    # Lowest\n    #\n    low_freq = freq-(bw/2.0)\n    low_freq /= 1.0e6\n    low_freq += (f_off/2.0)\n    \n    #\n    # Number of subbands\n    #\n    sub_bands=fbsize\n    \n    #\n    # Determine MJD from file timestamp\n    #\n    if (rx_time == None):\n        fp = open(outfile, \"wb\") #modo binario \n        t_start = (os.path.getmtime(outfile) / 86400) + 40587\n    else:\n        fp = open(outfile, \"wb\")\n        t_start = rx_time\n \n    #\n    # The rest here is mostly due to Guillermo Gancio ganciogm@gmail.com and fixed by Oscar Zamora (for Python 3)\n    #\n    stx=\"HEADER_START\".encode(\"utf-8\")\n    etx=\"HEADER_END\".encode(\"utf-8\")\n    fp.write(struct.pack('i', len(stx))+stx)\n    fp.flush()\n    #--\n    aux=\"rawdatafile\".encode(\"utf-8\")\n    aux=struct.pack('i', len(aux))+aux\n    fp.write(aux)\n    fp.write(struct.pack('i', len(outfile.encode(\"utf-8\")))+outfile.encode(\"utf-8\"))#outfile is str---> decode to byte in order to get (byte+byte) \n    #--\n    aux=\"src_raj\".encode(\"utf-8\")\n    aux=struct.pack('i', len(aux))+aux\n    source_ra = convert_sigproct(source_ra)\n    fp.write(aux)\n    aux=struct.pack('d', source_ra)\n    fp.write(aux)\n    fp.flush()\n\n    #--\n    aux=\"src_dej\".encode(\"utf-8\")\n    aux=struct.pack('i', len(aux))+aux\n    fp.write(aux)\n    source_dec= convert_sigproct(source_dec)\n    aux=struct.pack('d', source_dec)\n    fp.write(aux)\n    #--\n    aux=\"az_start\".encode(\"utf-8\")\n    aux=struct.pack('i', len(aux))+aux\n    fp.write(aux)\n    aux=struct.pack('d', 0.0)\n    fp.write(aux)\n    #--\n    aux=\"za_start\".encode(\"utf-8\")\n    aux=struct.pack('i', len(aux))+aux\n    fp.write(aux)\n    aux=struct.pack('d', 0.0)\n    fp.write(aux)\n    #--\n    aux=\"tstart\".encode(\"utf-8\")\n    aux=struct.pack('i', len(aux))+aux\n    fp.write(aux)\n    aux=struct.pack('d', float(t_start))\n    fp.write(aux)\n    #--\n    aux=\"foff\".encode(\"utf-8\")\n    aux=struct.pack('i', len(aux))+aux\n    fp.write(aux)\n    aux=struct.pack('d', f_off)\n    fp.write(aux)\n    #--\n    aux=\"fch1\".encode(\"utf-8\")\n    aux=struct.pack('i', len(aux))+aux\n    fp.write(aux)\n    aux=struct.pack('d', high_freq)\n    fp.write(aux)\n    #--\n    aux=\"nchans\".encode(\"utf-8\")\n    aux=struct.pack('i', len(aux))+aux\n    fp.write(aux)\n    aux=struct.pack('i', sub_bands)\n    fp.write(aux)\n    #--\n    aux=\"data_type\".encode(\"utf-8\")\n    aux=struct.pack('i', len(aux))+aux\n    fp.write(aux)\n    aux=struct.pack('i', 1)\n    fp.write(aux)\n    #--\n    aux=\"ibeam\".encode(\"utf-8\")\n    aux=struct.pack('i', len(aux))+aux\n    fp.write(aux)\n    aux=struct.pack('i', 1)\n    fp.write(aux)\n    #--\n    aux=\"nbits\".encode(\"utf-8\")\n    aux=struct.pack('i', len(aux))+aux\n    fp.write(aux)\n    aux=struct.pack('i', smpsize*8)\n    fp.write(aux)\n    #--\n    aux=\"tsamp\".encode(\"utf-8\")\n    aux=struct.pack('i', len(aux))+aux\n    fp.write(aux)\n    aux=struct.pack('d', tsamp)\n    fp.write(aux)\n    #--\n    aux=\"nbeams\".encode(\"utf-8\")\n    aux=struct.pack('i', len(aux))+aux\n    fp.write(aux)\n    aux=struct.pack('i', 1)\n    fp.write(aux)\n    #--\n    aux=\"nifs\".encode(\"utf-8\")\n    aux=struct.pack('i', len(aux))+aux\n    fp.write(aux)\n    aux=struct.pack('i', 1)\n    fp.write(aux)\n    #--\n    aux=\"source_name\".encode(\"utf-8\")\n    fp.write(struct.pack('i', len(aux))+aux)\n    fp.write(struct.pack('i', len(source_name.encode(\"utf-8\")))+source_name.encode(\"utf-8\"))#source_name is str---> decode to byte \n    #--\n    aux=\"machine_id\".encode(\"utf-8\")\n    aux=struct.pack('i', len(aux))+aux\n    fp.write(aux)\n    aux=struct.pack('i',backend) #20=CHIME-PSR (original code)\n    fp.write(aux)\n    #--\n    aux=\"telescope_id\".encode(\"utf-8\")\n    aux=struct.pack('i', len(aux))+aux\n    fp.write(aux)\n    aux=struct.pack('i', antenna) #20=CHIME (original code)\n    fp.write(aux)\n    #--\n    fp.write(struct.pack('i', len(etx))+etx)\n    #fp.flush() is not working here \n    #fp.close   is not working here \n    return True\n   \ndef auto_to_freqs(mask, freq, bw): #bw is float \n    start = freq+(bw/2)\n    bins = len(mask)\n    decr = bw/bins\n    flist = \"\"\n    for i in range(len(mask)):\n        if (mask[i] == 0.0):\n            flist += \"%8.4f,\" % (start/1.0e6)\n        start -= decr\n    return flist\n#\n# We're called fairly frequently, but we only want to log every 10 seconds\n#\nnext_fft = time.time() + 10.0\nsmooth_fft = [0.0]\nfft_cnt = 0\nlast_smooth = time.time()\ndef log_fft(freq,bw,prefix,fft):\n    global next_fft\n    global automask\n    global smooth_fft\n    global fft_cnt\n    global last_smooth\n    \n    #\n    # Degenerate FFT length--sometimes on startup\n    #\n    if (len(fft) < 2):\n        return\n    \n    #\n    # Provide \"smooth\" FFT for get_correction\n    #  function\n    #\n    if ((time.time() - last_smooth) >= 1.5):\n        if (len(smooth_fft) != len(fft)):\n            smooth_fft = numpy.array([0.0]*len(fft))\n        fft_cnt += 1\n        smooth_fft = numpy.add(fft,smooth_fft)\n        last_smooth = time.time()\n    #\n    # Not yet time\n    #\n    if (time.time() < next_fft):\n        return\n    \n    #\n    # Schedule our next one\n    #\n    next_fft = time.time() + 10.0 \n \n    #\n    # Get current time, break out into \"struct tm\" style time fields\n    #\n    ltp = time.gmtime(time.time())\n    \n    #\n    # Constract filename from parts\n    #\n    date = \"%04d%02d%02d%02d\" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday, ltp.tm_hour)\n    fp = open(prefix+\"psr-\"+date+\"-fft.csv\", \"a\")\n    \n    #\n    # Write UTC header\n    #\n    fp.write(\"%02d:%02d:%02d,\" % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec))\n    \n    #\n    # Spectrum is inverted:  Fc+bw/2 to Fc-bw/2\n    #\n    # Required for PRESTO tooling\n    # So we start at the high end and work our way backwards\n    #\n    for i in range(len(fft)-1,-1,-1):\n        if (fft[i] <= 0.0):\n            fp.write(\"??,\")\n        else:\n            fp.write(\"%.2f,\" % (10.0*math.log10(fft[i]/len(fft))))\n    fp.write(\"\\n\")\n    fp.close()\n\n    mf = open (prefix+\"psr-\"+date+\"-automask.txt\", \"w\")\n    mf.write (auto_to_freqs(automask,freq,bw))\n    mf.close()\n\n\n\n#\n# This is called from a 10s-of-Hz poll with a list of \"current_tags\"\n#\n# We record the time that the first tag flashes past us.\n#\n#\n# We maintain a static tag dictionary for use later by the header\n#  update code\n#\n\ntag_dict = {} \nfirst_tag = None\n\ndef process_tag(tags):\n    global first_tag\n    for tag in tags:\n        key = pmt.to_python(tag.key)\n        value = pmt.to_python(tag.value)\n        tag_dict[key] = value\n        #log_message(f\"Tag recibido: {key} = {value}\") only for debug \n\n        if first_tag is None:\n            first_tag = time.time()\n            #log_message(f\" first_tag registrado: {first_tag}\") only for debug \n\n    \n#\n# Used to find a tag in the tag_dict\n#\ndef get_tag(key):\n    if (key in tag_dict):\n        return (tag_dict[key])\n    else:\n        return None\n        \ndidit = False\n#\n# Basically, near the end of the run, concatenates the correct header data\n#  and the live sample data, and produces a final \".fil\" output file.\n#\n#only used in debuging\n\"\"\"LOG_FILEe = \"/home/cn5g/pulsar_filterbank/logs/update_header.txt\"\n\ndef log_message2(message2):\n    with open(LOG_FILEe, \"a\") as log:\n        log.write(message2 + \"\\n\")\n\"\"\"\ndef update_header(pacer, runtime, smpsize,test,fbsize,fbrate,outfile):\n    global didit\n    global first_tag\n    global smpwidth\n\n    if smpwidth == 0:\n        smpwidth = smpsize\n\n    if runtime is not None:\n        if first_tag is None:\n            return None\n        else:\n            endtime = first_tag + runtime - 0.5 \n \n    else:\n        endtime = time.time() - 30.0\n    #if (time.time() >= endtime and not didit and  test==1) or (time.time() >= endtime and not didit and test==0 and os.path.getsize((header_args[\"outfile\"]).replace(\".fil\", \".filtmp\"))>=fbsize*fbrate*smpsize*runtime-500) or (time.time() >= endtime and not didit and test==2):    \n    if time.time() >= endtime and not didit: \n    #Will create header and concatenate filterbank data \n    #if you are using a not very powerful pc (for high sample rates), runtime!=endtime, so your .fil data will be incomplete. Seconds even minutes will be lost!! \n\n        # Time MJD\n        times = get_tag(\"rx_time\")\n        if times is not None:\n            seconds = float(times[0]) + float(times[1])\n        else:\n            seconds = first_tag if first_tag is not None else time.time()\n            #No rx_time, time aprox\n        MJD = seconds / 86400.0 + 40587.0\n\n        build_header_info(\n            header_args[\"outfile\"],\n            header_args[\"source_name\"],\n            header_args[\"source_ra\"],\n            header_args[\"source_dec\"],\n            header_args[\"freq\"],\n            header_args[\"bw\"],\n            header_args[\"fbrate\"],\n            header_args[\"fbsize\"],\n            MJD, smpsize,\n            header_args[\"antenna\"],\n            header_args[\"backend\"]\n        )\n        dataname = header_args[\"outfile\"].replace(\".fil\", \".filtmp\")\n        try:\n            \n            #\n            # Concatenate the live sample data onto the .fil file, which\n            #   at this point, only contains the header data\n\n            \tinf = open(dataname, \"rb\")\n            \toutf = open(header_args[\"outfile\"], \"ab\")\n            \tif test!=2:\n            \t\tshutil.copyfileobj(inf, outf)\n            \tinf.close()\n            \toutf.close()\n            \t#if os.path.getsize(dataname)>fbsize*fbrate*smpsize*runtime and test==1:\n            \tif test==1 or test==2:\n            \t\tdidit = True\n            \tif test==0 and os.path.getsize(header_args[\"outfile\"])>fbsize*fbrate*smpsize*runtime:\n            \t\tdidit= True\n            #log_message2(f\"copiandooo\")\n            #didit = True #apaño porque los datos tardan mas en cogerse que el tiempo de run \n            #\n            # We don't need the \".filtmp\" file anymore, blow it away\n            #\n            #os.remove(dataname)###line anull debuging\n            #log_message2(f\" bytes concatenados correctamente en {header_args['outfile']} ({os.path.getsize(header_args['outfile'])} bytes)\")\n  \n\n        except:\n            pass\n\n    return None\n\ndef get_swidth():\n    return smpwidth\n\n#\n# Calculate a \"static\" RFI mask--basically a vector of either 1.0 or 0.0\n#   depending on whether this bin is \"in\" or excised\n#\n# Input is an RFI list, as a string, with comma-separated frequency values\n#   in Hz.\n#\n# This mask will get multiplied by the filterbank outputs--so at a position\n#   with a \"1.0\", that filterbank bin will be included, else it won't.\n#\ndef static_mask(freq,bw,fbsize,rfilist):\n    \n    #\n    # If no RFI list, the mask is all 1.0\n    #\n    if (rfilist == \"\" or len(rfilist) == 0 or rfilist == None):\n        return ([1.0]*fbsize)\n    \n    #\n    # Step size is the bandwidth over the filterbank size\n    #   (bin width, basically, in Hz)\n    #\n    step = bw/fbsize\n    start = freq-(bw/2.0)\n    end = freq+(bw/2.0)\n    \n    #\n    # Parse the RFI list, do a little sanity checking\n    #  on the values.\n    #\n    rfi = rfilist.split(\",\")\n    mask = [1.0]*fbsize\n    for r in rfi:\n        try:\n            ndx = float(r)-start\n            ndx = ndx/step\n            ndx = int(ndx)\n            if (ndx >= 0 and ndx < len(mask)):\n                mask[ndx] = 0.0\n        except:\n            pass\n    mask.reverse()\n    return(mask)\n\n#\n# Compute a \"dynamic mask\".  This is part of a two-stage process for\n#  implementing spectral-based RFI excision.  The first stage \"blanks\"\n#  the excised channels.  The second stage arranges for the \"blanked\"\n#  channels to have a median estimate +/- a small amount of noise\n#  in them.  This is better than a sudden \"empty\" channel for post-facto\n#  folding.\n#\n# Since this second mask is incorporated by a vector addition operation, the\n#  \"good\" channels will have a 0.0 in the mask, and the \"bad\" channels\n#  will have the locally-estimated mean in them.\n#\ncount=0\ndeviation=0.0\nautomask=None\ncurrent_estimate=0.0\ndef dynamic_mask(fft,smask,thresh):\n    global count\n    global deviation\n    global automask\n    global current_estimate\n   \n\n    if (automask == None):\n        automask = [1.0]*len(fft)\n    \n    #\n    # Our ultimate mask is based on both the user-input static mask\n    #  and the dynamically-determined mask\n    #\n    smask = list(numpy.multiply(smask,automask))\n    \n    #\n    # How many blanked/excised channels in the static mask?\n    #\n    nzero = smask.count(0.0)\n    \n    #\n    # Determine trim range\n    #\n    lf = len(fft)\n    ff = int(lf/10)\n    if (ff == 0):\n        ff = 1\n    \n    #\n    # Calculate mean deviation, but only occasionally\n    # Update automask, but only occasionally\n    #\n    if ((count % 15) == 0):\n        #\n        # Make \"trimmed\" versions of mask and input FFT\n        #\n        trim_fft = fft[ff:-ff]\n        trim_mask = list(smask[ff:-ff])\n        \n        #\n        # Compute a quick mean\n        # Since the trim_fft bins at the trim_mask excision locations will\n        #    be zero, we can use \"sum\" with confidence\n        #\n        #\n        # The count for the mean will be the length of the input,\n        #   minus the number of zeros in the mask\n        #\n        mcount = len(trim_fft)-trim_mask.count(0.0) #es int\n        dmean = sum(numpy.multiply(trim_fft,trim_mask))\n        dmean /= mcount\n        \n        #\n        # Now compute average deviation\n        #\n        adev = 0.0\n        for i in range(len(trim_fft)):\n            if (trim_mask[i]):\n                adev += abs(trim_fft[i]-dmean)\n        \n        #\n        # Automask looks for FFT values that exceed the current\n        #  mean estimate by a significant factor--a pulsar will\n        #  never do this.  Sporadic narrowband RFI will.\n        #\n        #\n        for i in range(len(fft)):\n            \n            #\n            # Bigger than threshold? It goes on the automask\n            #  AND NEVER LEAVES!  This prevents oscillation\n            #  over timescales that would be similar to pulsars...\n            #\n            if (fft[i] > (dmean*thresh)):\n                automask[i] = 0.0\n        \n        #\n        # Two-point smoothing on deviation\n        #\n        if (deviation != 0.0):      \n            deviation += adev/mcount\n            deviation /= 2.0\n        else:\n            deviation = adev/mcount\n\n    count +=1\n\n    #\n    # Compute the mean\n    # First: apply the mask\n    #\n    # We add up all the non-masked channels\n    #\n    mean = numpy.multiply(smask,fft)\n    mean = mean[ff:-ff]\n    lnm = len(mean)\n    mean = sum(mean)\n    \n    #\n    # Then: divide by length - count of blanked channels\n    #  (divide by count of non-masked channels, IOW)\n    #\n    mean = mean/float(lnm-nzero)\n    mask = [0.0]*len(smask)\n    current_estimate = mean\n    i = 0\n    if False:\n        for s in smask:\n            \n            #\n            # We apply the locally-estimated mean, and then dither by a\n            #  small amount--this makes sure that the correlation of the\n            #  blanked channels tends to be poor.  I hope.\n            #\n            if (s < 1.0):\n                mask[i] = random.uniform(mean-(deviation/2.0),mean+(deviation/2.0))\n            i += 1\n    \n    return(smask)\n    \ndef invert_rfi_mask(mask):\n    rmask = []\n    for i in range(0,len(mask)):\n        rmask.append(1.0 if mask[i] == 0.0 else 0.0)\n    return rmask\n\nestithen = time.time()\nfrozen_estimate = 0.0   \ndef get_current_estimate():\n    global current_estimate\n    global frozen_estimate\n    \n    if (time.time() - estithen < 90):\n        frozen_estimate = current_estimate\n        return current_estimate\n    else:\n        return frozen_estimate\n\n#\n# Compute passband flatness correction\n#\n# Use the middle 8 bins as an average to normalize to\n#\nlast_correct = time.time()\ncorrect_state = 0\ncorrection = [0.0]\ndef get_correction(fbsize,correct,pacer):\n    global last_correct\n    global smooth_fft\n    global fft_cnt\n    global correct_state\n    global correction\n    #\n    # They haven't asked for correction\n    #\n    if (correct == 0):\n        return [1.0]*fbsize\n    \n    #\n    # If time to return a correction estimate\n    #\n    if ((time.time() - last_correct) > 90):\n        # Compute correction if we haven't already done so\n        if (correct_state == 0):\n            correct_state = 1\n            \n            #\n            # Compute the fraction of the buffer we're ignoring\n            #  for calculation of the average level\n            #\n            frac = int(fbsize/6)\n            \n            #\n            # Reduce smooth by fft_cnt\n            #\n            smooth_fft = numpy.divide(smooth_fft,fft_cnt)\n            fft_cnt = 1\n            \n            #\n            # Produce the \"window\" over which we'll average\n            #\n            avg_window = smooth_fft[frac:-(frac)]##### +1 on -frac can save us from div/0\n            \n            #\n            # Average that \"window\"\n            #\n            avg = sum(avg_window)\n            avg /= float(len(avg_window))\n            \n            \n            #\n            # Compute the ratio between the average and the smoothed FFT, and\n            #  produce a scaling vector that makes them all roughly at the same level\n            #\n            # We only do thiS ONCE in an entire run near the beginning,\n            #   otherwise, other bad things will happen\n            #\n            # This should be OK, since the *ratios* should remain roughly\n            #  the same, even if the baseline noise level changes, due to\n            #  background continuum level changes, etc.\n            #\n            correction = numpy.divide([avg]*fbsize,smooth_fft)\n        return correction\n    #\n    # Not yet time, return no correction\n    #\n    else:\n        return [1.0]*fbsize\n    \ndef get_sky_freq(sky,freq):\n    return sky if sky != 0.0 else freq\n\ndef autoscale(scale,pace):\n    p = get_current_estimate()\n    if (p > 1.0e-12):\n        return float(scale/p)\n    else:\n        return 1.0\n\ncurrent_channel = 0\ndef get_current_channel(pacer,nchan):\n    global current_channel\n    \n    r = [0.0]*nchan\n    r[current_channel] = 1.0\n    current_channel += 1\n    if (current_channel >= nchan):\n        current_channel = 0\n    return r\n\nchannels = None\nchcnts = None\nspikes = None\nlastchan = -1\ndef analyser(fft,nchan):\n    global automask\n    global channels\n    global chcnts\n    global spikes\n    global lastchan\n    \n    nfft = fft[0:int(len(fft)/2)]\n    if channels == None:\n        channels = [numpy.array([0.0]*len(nfft))]*nchan\n        chcnts = [0.0]*nchan\n        spikes = [0]*nchan\n    \n    ccn = current_channel\n    channels[ccn] = numpy.add(nfft,channels[ccn])\n    chcnts[ccn] += 1.0\n    \n    #\n    # Ignore if this is the first data after a channel change\n    #\n    if (ccn != lastchan):\n        #print \"New channel %d\" % ccn\n        lastchan = ccn\n        return ccn\n    \n    chavg = numpy.divide(channels[ccn], chcnts[ccn])\n    \n    spike = 0\n    winsize = 6\n    if (chcnts[ccn] > 10):\n        for inspected in range(winsize,len(chavg)-winsize):\n            window = sum(chavg[inspected-winsize:inspected-1])\n            window /= float(winsize)\n            if (chavg[inspected] > window*3.5):\n                spike += 1\n \n        if (spike == 0):\n            if (spikes[ccn] > 0):\n                spikes[ccn] -=1\n\n        elif (spike > 1):\n            spikes[ccn] += 1\n\n        if (spikes[ccn] > 10):\n            automask[ccn] = 0.0\n\n    return ccn\n\n"
  states: {}
- name: fft_probe
  id: blocks_probe_signal_vx
  parameters:
    comment: |-
      This operates at fbrate
      Used for FFT logging
      And estimation of the mean
    type: float
    vlen: fbsize
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: an_fftsize
    forward: 'True'
    shift: 'True'
    type: float
    window: window.blackmanharris(an_fftsize)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fbsize
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fbsize)
  states: {}
- name: freq
  id: parameter
  parameters:
    label: Obs. Frequency
    type: eng_float
    value: 3.025e9
  states: {}
- name: hp
  id: parameter
  parameters:
    label: HP pass enable
    type: intx
    value: '1'
  states: {}
- name: hpgain
  id: parameter
  parameters:
    label: High Pass pseudo-gain
    type: eng_float
    value: '0.6'
  states: {}
- name: ifgain
  id: parameter
  parameters:
    label: IF Gain
    type: eng_float
    value: '10'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import time
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import platform
  states: {}
- name: import_0_1
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import atexit
  states: {}
- name: import_1_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: integrator
  id: parameter
  parameters:
    label: Enable straight integrator instead of IIR
    type: intx
    value: '0'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      A sub-graph to do analysis of the
      *detected* spectrum.

      This allows us to look for RFI components in a
      channel that may be only a wee bit above the
      average noise floor, and thus may fail to
      trigger the RF spectral excision.

      One channel is analysed at a time, in a
      round-robin schedule.

      This eliminates having to have <fbsize>
      independent FFTs running in parallel.
  states: {}
- name: note_1
  id: note
  parameters:
    comment: |-
      The trick here is to decimate the input so that
      the input to the tag_debug is slowed down to
      10-15SPS, via the keep-one-in-N.

      This is because tag_debug resets its
      local cache of tags every time its work
      function is called, which at high sample
      rates means 0 probability of catching it
      in a "full" state.
  states: {}
- name: note_1_0
  id: note
  parameters:
    comment: |-
      Sin ampli:
      -Apuntado a la Univ Privada 
      Gain_buena=45
      T=3600
      -Apuntado al polideportivo UPNA
      Gain_buena=?
      T=3600

      Con ampli:
      Apuntado a la privada 
      Gain_max=25 si no explota el codigo y da error div/0
  states: {}
- name: note_1_0_0
  id: note
  parameters:
    comment: |-
      Sample Rate = Band width, por Niquist 

      BW bajo para no meter ruido y BW< Max Int. BW (de MURMUR)

      Roll of correction=0 , si desaparece señal de los canales laterales, pero ahora esta arreglado

      16bit output=0 ,no va bien

      Thresh=2.5, asi el ruido es muy bajo en la FFT

      Detector scaling--->hace mas picuda la gaussina, mejor =1

      HP pass enable=1 lo pasa por un filtro que lo suaviza y aumenta la alta frecuencia

      Integrating=0 , al integrar si estas en un lugar ruidoso, se llena todo de ruido la FFT
  states: {}
- name: note_1_0_0_0
  id: note
  parameters:
    comment: |-
      WARNING: HIGH SAMPLE RATE 
      RUNTIME!=REALRUNTIME
  states: {}
- name: note_1_0_0_0_0
  id: note
  parameters:
    comment: Cosas que es mejor que no toques si no lo necesitar
  states: {}
- name: note_1_0_0_0_0_0
  id: note
  parameters:
    comment: |-
      Current dir=./
      Observations folder=pulsar_filterbank/observations/  !not working
      Dir at home =obs/
      USB=/media/cn5g/KINGSTON/
  states: {}
- name: note_1_0_0_0_0_0_0
  id: note
  parameters:
    comment: |-
      1= Original code (powerful PCs)
      2= Copy later code (non poweful PCs)
      you have to copy .filtmp on .fil file using code.
  states: {}
- name: note_1_0_0_1
  id: note
  parameters:
    comment: Set-up parameters. CHANGE IF SET-UP WILL BE MODIFIED
  states: {}
- name: note_1_0_0_1_0
  id: note
  parameters:
    comment: |-
      20=CHIME
      66=YEBES40m
      67=RAEGE 13m Yebes
      68=RAEGE 13m Santa Maria
  states: {}
- name: note_1_0_0_1_0_0
  id: note
  parameters:
    comment: |-
      20=CHIME-PSR
      66=YEBES-SDR
  states: {}
- name: osmo_radio
  id: osmosdr_source
  parameters:
    args: '"bladerf=0,nchan=1"'
    bb_gain0: bbgain
    bw0: samp_rate
    freq0: IF
    gain0: rfgain
    gain_mode0: 'False'
    if_gain0: ifgain
    sample_rate: samp_rate
    sync: sync
    time_source0: pps
    type: fc32
  states: {}
- name: p0
  id: parameter
  parameters:
    label: Pulsar P0
    type: eng_float
    value: '0.71452'
  states: {}
- name: pinterval
  id: parameter
  parameters:
    label: Interval for logging profile
    type: intx
    value: '30'
  states: {}
- name: pps
  id: parameter
  parameters:
    label: PPS source
    value: '"internal"'
  states: {}
- name: prefix
  id: parameter
  parameters:
    label: File prefix
    value: '"./"'
  states: {}
- name: profile
  id: parameter
  parameters:
    label: Log Rough Profile
    type: intx
    value: '0'
  states: {}
- name: pw50
  id: parameter
  parameters:
    label: Pulsar PW50
    type: eng_float
    value: '6.6e-3'
  states: {}
- name: ra
  id: parameter
  parameters:
    label: Source RA
    type: eng_float
    value: '3.52'
  states: {}
- name: refclock
  id: parameter
  parameters:
    label: Reference Clock Source
    value: '"internal"'
  states: {}
- name: resolution
  id: parameter
  parameters:
    label: FB resolution multiplier
    type: intx
    value: '14'
  states: {}
- name: rfgain
  id: parameter
  parameters:
    label: RF Gain
    type: eng_float
    value: '4'
  states: {}
- name: rfilist
  id: parameter
  parameters:
    label: RFI frequency list
    value: '""'
  states: {}
- name: rolloff
  id: parameter
  parameters:
    label: Enable Roll-off correction
    type: intx
    value: '1'
  states: {}
- name: runtime
  id: parameter
  parameters:
    label: Total runtime (seconds)
    type: intx
    value: 60*20
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0-math.pow(math.e,-2.0*(lpcorner/(fft_rate)))
    comment: A bit of low-pass filtering
    type: float
    vlen: fbsize
  states: {}
- name: single_pole_iir_filter_xx_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0-math.pow(math.e,-2.0*(hpcorner/(fbrate)))
    type: float
    vlen: fbsize
  states: {}
- name: single_pole_iir_filter_xx_2
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0-math.pow(math.e,-2.0*(20.0/fbrate))
    type: float
    vlen: fbsize
  states: {}
- name: single_pole_iir_filter_xx_3
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.1'
    type: float
    vlen: an_fftsize
  states: {}
- name: single_pole_iir_filter_xx_4
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0/5.0
    type: float
  states: {}
- name: sky
  id: parameter
  parameters:
    label: Sky Frequency
    type: eng_float
    value: '0'
  states: {}
- name: source
  id: parameter
  parameters:
    label: Source Name
    type: str
    value: '"B0329+54"'
  states: {}
- name: srate
  id: parameter
  parameters:
    label: Hardware Sample Rate
    type: eng_float
    value: 50.0e6
  states: {}
- name: subdev
  id: parameter
  parameters:
    label: Subdev spec, UHD-version only
    value: '"A:0"'
  states: {}
- name: tag_retrieve
  id: blocks_tag_debug
  parameters:
    display: 'False'
    filter: ''
    type: complex
  states: {}
- name: tbins
  id: parameter
  parameters:
    label: Number of time bins for profile
    type: intx
    value: '250'
  states: {}
- name: test
  id: parameter
  parameters:
    label: copying issies case
    type: intx
    value: '2'
  states: {}
- name: thresh
  id: parameter
  parameters:
    label: RFI detection threshold--linear factor
    type: eng_float
    value: '2.5'
  states: {}
- name: trial_ppms
  id: parameter
  parameters:
    label: List of trial ppms
    value: '"0.0"'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: iq
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: d_mags
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: f_mags
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: pre_d_mags2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: iq
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: d_mags
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: d_mags
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: f_mags
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: pre_d_mags2
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: f_mags
  states: {}
- name: wide
  id: parameter
  parameters:
    label: Enable 16-bit output
    type: intx
    value: '0'
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_abs_xx_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_abs_xx_1, '0', blocks_float_to_char_0, '0']
- [blocks_abs_xx_1, '0', blocks_float_to_short_0, '0']
- [blocks_abs_xx_1, '0', blocks_keep_one_in_n_3, '0']
- [blocks_add_xx_0, '0', tag_retrieve, '0']
- [blocks_add_xx_1, '0', virtual_sink_1, '0']
- [blocks_add_xx_2, '0', blocks_sub_xx_0, '0']
- [blocks_add_xx_2, '0', single_pole_iir_filter_xx_1, '0']
- [blocks_complex_to_float_0, '0', blocks_float_to_complex_0, '1']
- [blocks_complex_to_float_0, '1', blocks_float_to_complex_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_complex_to_mag_squared_1, '0', single_pole_iir_filter_xx_3, '0']
- [blocks_float_to_char_0, '0', blocks_file_sink_0, '0']
- [blocks_float_to_complex_0, '0', virtual_sink_0, '0']
- [blocks_float_to_short_0, '0', blocks_file_sink_0_0, '0']
- [blocks_head_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_4, '0']
- [blocks_integrate_xx_1, '0', single_pole_iir_filter_xx_4, '0']
- [blocks_keep_one_in_n_0, '0', blocks_multiply_const_vxx_3, '0']
- [blocks_keep_one_in_n_1, '0', blocks_add_xx_0, '0']
- [blocks_keep_one_in_n_2, '0', blocks_multiply_const_vxx_5, '0']
- [blocks_keep_one_in_n_3, '0', blocks_vector_to_stream_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_2, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_const_vxx_2, '0', blocks_add_xx_2, '1']
- [blocks_multiply_const_vxx_3, '0', blocks_add_xx_1, '0']
- [blocks_multiply_const_vxx_4, '0', virtual_sink_3, '0']
- [blocks_multiply_const_vxx_5, '0', blocks_vector_to_stream_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_1, '0', blocks_abs_xx_0, '0']
- [blocks_stream_to_vector_2, '0', fft_vxx_0, '0']
- [blocks_sub_xx_0, '0', blocks_abs_xx_1, '0']
- [blocks_tags_strobe_0, '0', blocks_add_xx_0, '1']
- [blocks_vector_to_stream_0, '0', blocks_integrate_xx_1, '0']
- [blocks_vector_to_stream_1, '0', Folder_Block, '0']
- [copyblock, '0', blocks_complex_to_float_0, '0']
- [copyblock, '0', blocks_keep_one_in_n_1, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_1, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [osmo_radio, '0', copyblock, '0']
- [single_pole_iir_filter_xx_0, '0', virtual_sink_2, '0']
- [single_pole_iir_filter_xx_1, '0', blocks_multiply_const_vxx_1, '0']
- [single_pole_iir_filter_xx_2, '0', fft_probe, '0']
- [single_pole_iir_filter_xx_3, '0', analysis_probe, '0']
- [single_pole_iir_filter_xx_4, '0', blocks_stream_to_vector_2, '0']
- [virtual_source_0, '0', blocks_head_0, '0']
- [virtual_source_1, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_1_0, '0', single_pole_iir_filter_xx_2, '0']
- [virtual_source_2, '0', blocks_keep_one_in_n_0, '0']
- [virtual_source_3, '0', blocks_add_xx_1, '1']
- [virtual_source_4, '0', blocks_keep_one_in_n_2, '0']

metadata:
  file_format: 1
